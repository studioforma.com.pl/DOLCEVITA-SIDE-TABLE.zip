Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Dolcevita - Side table 45x45 - ver4.ifc
Time: 2024-01-11T11:43:19
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Dolcevita - Side table 45x45 - model_0 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_1 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_2 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_3 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_4 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_5 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_6 - ObjectType: SketchupGroup
 | Dolcevita - Side table 45x45 - model_7 - ObjectType: SketchupGroup
